# IAR project OS3.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\..\BSP; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uCOS-III\Source; ..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOS-III.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\TM4C129X_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../: app.c app_cfg.h bsp_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_int.h bsp_led.c bsp_led.h bsp_sys.c bsp_sys.h cpu_bsp.c
  group BSP/IAR
    ../../BSP/IAR/: cstartup.c TM4C129X_FLASH.icf
  group uC-CPU
    ../../../../../uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/ARM-Cortex-M4/IAR
    ../../../../../uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC-LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-LIB/Ports/ARM-Cortex-M4/IAR
    ../../../../../uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../../../../../uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS-III/Source
    ../../../../../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
