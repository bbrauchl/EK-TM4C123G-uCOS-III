# Keil uVision project OS3.uvprojx, settings and files
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OS3
  c flags: Optim=3 v6Lang=5 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c include: ..\;..\..\BSP;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\..\uCOS-III\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../: app.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../../BSP/KeilMDK/: cstartup.s
    ../../BSP/driverlib/rvmdk/: driverlib.lib
    ../../BSP/: cpu_bsp.c
  group uC-CPU
    ../../../../../uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../../../../uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC-LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOS-III-Source
    ../../../../../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uCOS-III-Port
    ../../../../../uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
software components: CMSIS:CORE 5.1.2
